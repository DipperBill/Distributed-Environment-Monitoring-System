# Keil uVision project node.uvprojx, settings and files
target SPI (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\USER;..\HARDWARE\ADC;..\HARDWARE\AHT20;..\HARDWARE\BH1750;..\HARDWARE\ESP;..\HARDWARE\SPI;..\HARDWARE\SX127X
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/AHT20/: AHT20-21_DEMO_V1_3.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/ESP/: esp8266.c tcp.c mqtt.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SX127X/: SX127X_Driver.c SX127X_Hal.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_adc.c
